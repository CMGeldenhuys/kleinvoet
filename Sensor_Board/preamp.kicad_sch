File: Sensor_Board/preamp.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: big commit
Parts:
- gave numbers to parts that had none: 16
