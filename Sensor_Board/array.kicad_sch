File: Sensor_Board/array.kicad_sch (KiCad schematic)
At the start: 18 parts

Commit message: big commit
Parts:
- gave numbers to parts that had none: 10
