File: Sensor_Board/buffer.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: big commit
Parts:
- gave numbers to parts that had none: 15
